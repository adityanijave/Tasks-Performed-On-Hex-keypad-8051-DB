# Keil uVision project 4X4_Hexkey_Pad_number_Switchcase.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: 4X4_Hexkey_Pad_number_Switchcase +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 4X4_Hexkey_Pad_number_Switchcase.c
