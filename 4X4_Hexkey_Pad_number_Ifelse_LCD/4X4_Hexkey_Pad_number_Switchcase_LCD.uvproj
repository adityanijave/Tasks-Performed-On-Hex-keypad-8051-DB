# Keil uVision project 4X4_Hexkey_Pad_number_Switchcase_LCD.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: 4X4_Hexkey_Pad_number_Switchcase_LCD +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 lcd_8bit.h lcd_8bit.c delay.h 4X4_Hexkey_Pad_number_Switchcase_LCD_main.c delay.c 4X4_Hexkey_Pad_number.h 4X4_Hexkey_Pad_number.c
